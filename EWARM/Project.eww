<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LCD, LED and steppers IAR.ewp</path>
  </project>
  <batchBuild />
</workspace>
